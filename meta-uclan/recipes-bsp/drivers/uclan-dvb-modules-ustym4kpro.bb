SRCDATE = "20201218"

require uclan-dvb-modules-hisi.inc

SRC_URI[md5sum] = "b3b310eb6efefac710e27e59bbc5e3e1"
SRC_URI[sha256sum] = "07427d233bd1bc6eaef0677e037219868d2b73d474404dea70e6bf383abd274f"

COMPATIBLE_MACHINE = "^(ustym4kpro)$"
