SRCDATE = "20141203"

require ixuss-dvb-modules.inc

MACHINETYPE = "zero"

COMPATIBLE_MACHINE = "^(ixusszero)$"

SRC_URI[md5sum] = "a7ce142534ea44d896f7bacf523d1ee7"
SRC_URI[sha256sum] = "6f89d73cce1301a1601280b7ef826d811900c7f74f2266f2372bceb23bb4b003"
