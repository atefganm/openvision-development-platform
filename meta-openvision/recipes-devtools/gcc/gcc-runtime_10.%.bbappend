EXTRA_OECONF_append = " --with-specs=%{!fno-common:%{!fcommon:-fcommon}}"
