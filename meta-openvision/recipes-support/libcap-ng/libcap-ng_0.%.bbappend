FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

TARGET_LDFLAGS_sh4 += "-pthread"
