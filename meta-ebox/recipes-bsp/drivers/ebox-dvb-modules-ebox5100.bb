require ebox-dvb-modules.inc

COMPATIBLE_MACHINE = "^(ebox5100)$"

SRCDATE = "20150422"

SRC_URI[md5sum] = "9f2e9b2a541424c022ee1ffb18021be5"
SRC_URI[sha256sum] = "18565b369bc69d4657d52d6147bdb976453582c3214b1aa5faf347eafb43db9a"
