require ebox-dvb-modules.inc

COMPATIBLE_MACHINE = "^(ebox7358)$"

SRCDATE = "20150422"

SRC_URI[md5sum] = "b44e187b5146615e1331a87de3257b48"
SRC_URI[sha256sum] = "6f321daa60dc6ab0f3ac4f90377dedbea5ba8f408534f5e802887f313efadc3a"
