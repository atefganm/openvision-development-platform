require ebox-dvb-modules.inc

COMPATIBLE_MACHINE = "^(eboxlumi)$"

SRCDATE = "20150422"

SRC_URI[md5sum] = "d0fd7d99d6865f73c377772d90f5f30b"
SRC_URI[sha256sum] = "3f36b094d00bce2300c726e2da1c3db96df3f834a4715a652eb51a2d70155a03"

