SRCDATE = "20170614"

MACHINETYPE = "alphatriple"

require broadmedia-dvb-modules.inc

SRC_URI[md5sum] = "208093dad3f4be9a6fa5d1c4d0e46387"
SRC_URI[sha256sum] = "49c3b7d053fa23cd59ce5f38a7c5db9b0e873dcbf39fe5e8ae05600339f4d620"

COMPATIBLE_MACHINE = "^(alphatriplehd)$"
