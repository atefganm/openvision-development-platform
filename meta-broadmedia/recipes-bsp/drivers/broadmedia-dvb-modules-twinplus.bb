SRCDATE = "20170614"

MACHINETYPE = "twinplus"

require broadmedia-dvb-modules.inc

SRC_URI[md5sum] = "0192a1f3f6b50600e523678e41fc6d80"
SRC_URI[sha256sum] = "a965c6f2d8c8c766d872654dde0ef39d290a7c2c91c98f0faa44ae69d1e984db"

COMPATIBLE_MACHINE = "^(mbtwinplus)$"
