SRCDATE = "20170829"

MACHINETYPE = "7300s"

require ceryon-dvb-modules.inc

SRC_URI[md5sum] = "7313190013e47680cbfdbeecf6eca48e"
SRC_URI[sha256sum] = "61c1923c59888fa13c8139ca303ae8ed7f64df3c217a1a57261e84b8cb823118"

COMPATIBLE_MACHINE = "^(odin2hybrid)$"
