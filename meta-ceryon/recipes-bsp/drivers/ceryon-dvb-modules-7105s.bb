SRCDATE = "20180523"

MACHINETYPE = "7105s"

require ceryon-dvb-modules.inc

SRC_URI[md5sum] = "07b013e9daccca13e767a279c7c63090"
SRC_URI[sha256sum] = "471b0abf748fc676e26495d91e340b8317a368cfb0e8da76ec6f68d0f21ec761"

COMPATIBLE_MACHINE = "^(twinboxlcdci5)$"
