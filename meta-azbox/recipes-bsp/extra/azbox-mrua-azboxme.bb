require azbox-mrua.inc

COMPATIBLE_MACHINE = "^(azboxme)$"

SRCDATE = "3.11-1"

SRC_URI[md5sum] = "73f9840f5cfec6e0838eefdc2813dab3"
SRC_URI[sha256sum] = "49a531e062c41e901acdf29f80ab3db688bf89f228020b992c70823cf9d01436"
