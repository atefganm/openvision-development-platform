require azbox-dvb-modules.inc

COMPATIBLE_MACHINE = "^(azboxme)$"

SRCDATE = "17092013"

SRC_URI = "http://source.mynonpublic.com/azbox/${MACHINE}-dvb-modules-${KV}-oe-core-${SRCDATE}.tar.gz"

SRC_URI[md5sum] = "3d7b8d240626a08f16c170e5832be618"
SRC_URI[sha256sum] = "48b48a94094ecce34398efcee7e17e780d9cce0ecf1510758078ed4e18f9ce6d"
