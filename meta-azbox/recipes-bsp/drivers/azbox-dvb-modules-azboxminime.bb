require azbox-dvb-modules.inc

COMPATIBLE_MACHINE = "^(azboxminime)$"

SRCDATE = "17092013"

SRC_URI = "http://source.mynonpublic.com/azbox/${MACHINE}-dvb-modules-${KV}-oe-core-${SRCDATE}.tar.gz"

SRC_URI[md5sum] = "2c037462af10a7909f4c803a90b82a1d"
SRC_URI[sha256sum] = "7ac3c8ac567ffe627850fda0c6713dce71305886af6e3cc286800fbfc394709a"
