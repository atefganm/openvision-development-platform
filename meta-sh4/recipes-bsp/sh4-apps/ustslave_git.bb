DESCRIPTION = "Tool for uploading the firmware to the slave DSPs"

require sh4-apps.inc
require sh4-bin-install.inc

RDEPEND += "stslave-fw"
