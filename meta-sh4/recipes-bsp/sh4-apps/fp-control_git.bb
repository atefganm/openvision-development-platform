DESCRIPTION = "A tool for uploading the firmware to the slave DSPs"

SH4APPBIN = "fp_control"

require sh4-apps.inc
require sh4-bin-install.inc
