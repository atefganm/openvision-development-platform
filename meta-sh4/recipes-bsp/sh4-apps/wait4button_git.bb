require sh4-apps.inc
require sh4-bin-install.inc
