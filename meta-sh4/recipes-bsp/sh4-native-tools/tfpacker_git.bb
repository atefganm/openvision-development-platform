DESCRIPTION = "SH4 tfpacker tool for creating flashable images"

require sh4-native-tools.inc
