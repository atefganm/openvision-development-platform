DESCRIPTION = "SH4 pad tool for creating flashable images"

require sh4-native-tools.inc
