DESCRIPTION = "SH4 mup tool for creating flashable images"

require sh4-native-tools.inc
