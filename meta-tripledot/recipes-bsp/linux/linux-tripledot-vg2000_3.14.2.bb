SRCDATE = "20141208"

MACHINETYPE = "vg2000"

require linux-tripledot.inc

SRC_URI[md5sum] = "8e0385481057a214f0635c8b947dbb7d"
SRC_URI[sha256sum] = "6c782f1003a48c508832660b1053d68f3c616f5b1ece373d06125a0e7f47d23a"

COMPATIBLE_MACHINE = "^(xcombo)$"
