SRCDATE = "20141208"

MACHINETYPE = "vg1000"

require linux-tripledot.inc

SRC_URI[md5sum] = "58ab26c0ae0c791ce7e962f7f1ae4c3c"
SRC_URI[sha256sum] = "d53df9471aea4ae35644d96ef8c8425ad82001e0de8dc5b9fdac8f4b983d0232"

COMPATIBLE_MACHINE = "^(tyrant)$"
