SRCDATE = "20160217"

MACHINETYPE = "yh7362"

require linux-tripledot.inc

SRC_URI[md5sum] = "23781bce0ab453e7c18092f1f6dd2e2b"
SRC_URI[sha256sum] = "bf31e5b1c6e9295bdcd531b94a0f327f70b07bc901cd68dbc1730f04274a86d4"

COMPATIBLE_MACHINE = "^(evoslimse|sf98)$"
