SRCDATE = "20171007"

MACHINETYPE = "vg5000"

require tripledot-dvb-modules.inc

SRC_URI[md5sum] = "e49cdf6496466f95b5c0fa73eeed9617"
SRC_URI[sha256sum] = "49f13f730913457f2561917243b370c9f3ad121d2fb7e4d2520b7320f0be539c"

COMPATIBLE_MACHINE = "^(enibox|mago|sf108|x1plus)$"
