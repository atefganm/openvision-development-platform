SRCDATE = "20171007"

MACHINETYPE = "yh62tc"

require tripledot-dvb-modules.inc

SRC_URI[md5sum] = "e8c4d6dedd90d13bfbe7361f6b018ca4"
SRC_URI[sha256sum] = "e2498d26c68a9116339274bea2752f8a5c576daf492939abe7503d0472336e4c"

COMPATIBLE_MACHINE = "^(evoslimt2c)$"
