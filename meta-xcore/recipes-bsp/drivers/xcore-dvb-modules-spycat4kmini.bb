SRCDATE = "20170907"

KOFILES = "brcmstb-${MACHINE} ci ftm4862 fts260 sp988x fts3166"

COMPATIBLE_MACHINE = "^(spycat4kmini)$"

require xcore-dvb-modules.inc

SRC_URI[md5sum] = "1f3227bbd0e87a8ae1ab87326a51a1be"
SRC_URI[sha256sum] = "cb8176e38e9bf858adadc4a4514ec3aa4624bf7fb6b1074b245438eb92fafc5b"
