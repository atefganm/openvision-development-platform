SRCDATE = "20170907"

KOFILES = "brcmstb-${MACHINE} ci ftm4862 fts260 sp988x fts3166"

COMPATIBLE_MACHINE = "^(spycat4kcombo)$"

require xcore-dvb-modules.inc

SRC_URI[md5sum] = "dfa00eef188c215b201c318aedd4bf6b"
SRC_URI[sha256sum] = "c857c3c809fd66fb0c564b01d17dfb768580ddd0c3545e44ded3efb416c2e288"
