require et-blindscan-dvbc-utils.inc

COMPATIBLE_MACHINE = "^(et8000)$"

PV = "1.2"

SRC_URI[md5sum] = "459be6d6e8336d182de1ada4a8dfd3c0"
SRC_URI[sha256sum] = "8f67c7f79d8a4b9d7eea5a1574d1945e8c7c6eea5560cadb0566c4533e01bb12"
