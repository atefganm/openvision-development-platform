require et-blindscan-dvbc-utils.inc

COMPATIBLE_MACHINE = "^(et8500)$"

PV = "1.6"

SRC_URI[md5sum] = "04475b40f25460cead27285f103a0f50"
SRC_URI[sha256sum] = "2e0c285ee8768e8a342ca8ba97f3b1238e3ebc2dcb1b71c4803c532c94804478"
