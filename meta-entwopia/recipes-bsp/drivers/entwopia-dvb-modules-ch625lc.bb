SRCDATE = "20170831"

MACHINETYPE = "ch625lc"

require entwopia-dvb-modules.inc

SRC_URI[md5sum] = "1f983be6654d786c9c96ba45d64468ec"
SRC_URI[sha256sum] = "96a27f9cc02f2e533eaf79db56a85ad43bf2e87f84e5c7adad50de619beaed83"

COMPATIBLE_MACHINE = "^(evominiplus)$"
