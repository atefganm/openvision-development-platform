SRCDATE = "20200828"

require dinobot-dvb-modules2.inc

SRC_URI[md5sum] = "3d74ea33b35e4b00c33672b50a97ca11"
SRC_URI[sha256sum] = "2464ce94480d0ab4af92ccb8a797b1986903862b4ef122309655d1746c505b80"

COMPATIBLE_MACHINE = "^(dinoboth265|axashistwin|protek4kx1)$"
