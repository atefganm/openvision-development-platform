require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(vipersingle|viper4kv20|iziboxelite4k)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "fd3042e999bd6dd0f1e32444381ff685"
SRC_URI[sha256sum] = "75e3d07ba91ddde13035f453de01b803ead629e46008dc0fe1b66e4ac0015980"
