require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobot4kmini)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "18dc832c9122e00a54ad345f50e483a0"
SRC_URI[sha256sum] = "7bea15a4e6c877b6507f19273c44d21bbac166eec6f927b7ce3f889e37b35b5b"
