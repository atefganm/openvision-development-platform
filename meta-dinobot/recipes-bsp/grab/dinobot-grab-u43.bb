require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobotu43|turing)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "3af3c96b21c83dcc64b5a5fcc14fce69"
SRC_URI[sha256sum] = "fab6ae0dc4ba4fc421502049628bfefe05557ade900bb758ae59db88395dad25"
