require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobot4kse)$"

SRCDATE = "20180427"

SRC_URI[md5sum] = "50d1913c258eba331aa967c084d11575"
SRC_URI[sha256sum] = "4fd42fa116d37dacada95ee95d683d07604457cc74fa60ef191ec9768f35457a"
