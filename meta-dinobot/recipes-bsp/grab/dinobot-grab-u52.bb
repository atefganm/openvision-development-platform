require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashis4kcomboplus|dinobot4kplus)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "4523e9d2fa432b4465630227306d81a6"
SRC_URI[sha256sum] = "820a9a50a19cdaeea1878a6b505feae5d1aaab8011063d941c8b1635af3b92e0"
