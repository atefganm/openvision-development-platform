require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashis4kcombo|dinobot4kl|anadol4kv2)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "96eb79a1a1befab1c6d70327b5e3519e"
SRC_URI[sha256sum] = "bbd4ad83e432ec6deccfadcf2e30b4cdd2f4d14a5612345852b7be65549e4d13"
