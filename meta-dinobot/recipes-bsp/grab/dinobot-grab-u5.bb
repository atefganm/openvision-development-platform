require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobot4k|anadol4k)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "e4c8bf94ac64f7c022e5f0335d4a6b73"
SRC_URI[sha256sum] = "7312787aa1cd618ed1be85ea73384103c4a74a4b979859384a791fda0fc28c5f"
