require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(axashisc4k)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "a3d744dad854b434fee74c58873ec0d8"
SRC_URI[sha256sum] = "1c6db7259db3a7aebbdb07ed5045b31d9456b2685209386a46044eddfe345b6f"
