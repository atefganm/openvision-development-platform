require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(arivacombo)$"

SRCDATE = "20191212"

SRC_URI[md5sum] = "a10f5038ce7feca39b6472d84bd0eccc"
SRC_URI[sha256sum] = "2f29d167af28bd5be86b5d2d5d0d53f5d1703fd12ae4edb9fd3a550f5c6875fe"
