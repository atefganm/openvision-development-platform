require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobotu55|iziboxx3)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "5ab7009875ee85114dc1a73e6bcc3e72"
SRC_URI[sha256sum] = "4c2b23220313cb4e6848ad477e6f72b4574780bbdb540a429c3e449fe44118e4"
