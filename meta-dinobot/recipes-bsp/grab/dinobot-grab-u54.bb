require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinobot4kpro)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "7e088688f1eebd7e0a310a62a680f0f9"
SRC_URI[sha256sum] = "53c4084b78895687032acb49b77d1b7e5d58b4261edfc108b73810a81d885467"
