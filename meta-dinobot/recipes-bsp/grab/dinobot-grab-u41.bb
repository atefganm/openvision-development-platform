require dinobot-grab.inc

COMPATIBLE_MACHINE = "^(dinoboth265|axashistwin|protek4kx1)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "c86442303100d0db85196260ab600b98"
SRC_URI[sha256sum] = "425d448f262483788200a2c7064684fbf0d90d1a0b09177600d024dfa96b0b26"
