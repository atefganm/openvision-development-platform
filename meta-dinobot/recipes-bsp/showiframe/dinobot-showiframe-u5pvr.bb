require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobot4kse)$"

SRCDATE = "20180510"

SRC_URI[md5sum] = "2bec00ffb447ed1a31ab54d5054907ec"
SRC_URI[sha256sum] = "643813b005f446bd582d1391e8ce0f4d3dae7ed71a1279008add259b3c978e40"
