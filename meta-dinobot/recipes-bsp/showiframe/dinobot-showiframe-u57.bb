require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(vipersingle|viper4kv20|iziboxelite4k)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "390239691053a3f170aed42459ace3e7"
SRC_URI[sha256sum] = "4e08731e05a042c9ba6ead0f0e9d7eef1e37e819bb037768c9ddbe85f86734b7"
