require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobot4kpro)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "42a01e720d41ec7eb97d7a83d42682ca"
SRC_URI[sha256sum] = "23ba88e80a0c3702b04892f4169ad25de0a9786a8676f1d53b4f42b2ab883b7f"
