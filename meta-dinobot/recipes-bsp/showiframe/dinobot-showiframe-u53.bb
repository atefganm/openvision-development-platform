require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobot4kmini)$"

SRCDATE = "20200710"

SRC_URI[md5sum] = "e86b968fd7c4522d36ef567acf37c932"
SRC_URI[sha256sum] = "9ab1f2acabd8ae179a679cdf48880c43233d5e7ff9fc0593f43e59842c39c403"
