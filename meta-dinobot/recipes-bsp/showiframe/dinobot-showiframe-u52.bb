require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(axashis4kcomboplus|dinobot4kplus)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "85f5b7975ef8bd63c42ad9948e3655e4"
SRC_URI[sha256sum] = "0dce5c1ad8793e38661a82a56c0507112b0424f3dd5abebe2c6cb8a06953e241"
