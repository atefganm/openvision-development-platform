require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinoboth265|axashistwin|protek4kx1)$"

SRCDATE = "20201015"

SRC_URI[md5sum] = "9c0ebdafaae95de90055babdc10698d1"
SRC_URI[sha256sum] = "11c0693c6f8e6a5c6d96879111a604ba29351443b83030c5972cbc58648e4744"
