require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobotu55|iziboxx3)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "7b15249c1ba9c5a4bdf58f1d68f3a040"
SRC_URI[sha256sum] = "0f615a4c216c711c694d9b289dee65c1a865ef78c14bb3b13b58dfe3791cd2b9"
