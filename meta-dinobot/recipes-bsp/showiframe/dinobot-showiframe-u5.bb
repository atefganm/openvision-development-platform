require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "dinobot4k|anadol4k"

SRCDATE = "20200828"

SRC_URI[md5sum] = "77b59337e459b38df7072bcf7552776c"
SRC_URI[sha256sum] = "757956166e132ec60ade4c74ea56b1fe237727cda095c7cf998cabf697a355cf"
