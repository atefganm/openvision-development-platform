require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(axashis4kcombo|dinobot4kl|anadol4kv2)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "43ae850ca64bf6816aee450f15dfe603"
SRC_URI[sha256sum] = "8e375eab5939b11db79363b41a6d1c7fc26fd25a2f9e47b63b7e24e101ef5cb8"
