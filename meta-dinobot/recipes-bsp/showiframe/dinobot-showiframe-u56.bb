require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(axashisc4k)$"

SRCDATE = "20200828"

SRC_URI[md5sum] = "8bbeadd6172fdd5dd83c7ee0237066df"
SRC_URI[sha256sum] = "5ddde534f387a8d9b22b7770b4f9e38489040b3d3ecc9fd487249219bd38d6b6"
