require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(dinobotu43|turing)$"

SRCDATE = "20201015"

SRC_URI[md5sum] = "6c6e00fed68d7ae5a47844ede2c7f334"
SRC_URI[sha256sum] = "8c042e67d9a0603c47d31ccb127984085ca3828dd46c8864dc08b49fdeee5436"
