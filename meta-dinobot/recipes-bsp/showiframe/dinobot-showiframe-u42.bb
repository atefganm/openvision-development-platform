require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(anadolprohd5)$"

SRCDATE = "20201015"

SRC_URI[md5sum] = "6586f29ecd5a9f07d2c9f8f58e8f10ff"
SRC_URI[sha256sum] = "1df9354b11a78c7981e6a764b9a41daa3caa09637f155970598d455bc0c91b50"
