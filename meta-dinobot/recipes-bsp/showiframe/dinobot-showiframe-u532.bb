require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(arivacombo)$"

SRCDATE = "20191212"

SRC_URI[md5sum] = "db35b9ce7a45fc470d7e1d4ebc3ce8f6"
SRC_URI[sha256sum] = "a1593aad367519b289dd34ff54ef77dd8dab2bfc3691d7680dc3cddc1dd5841f"
