require dinobot-showiframe.inc

COMPATIBLE_MACHINE = "^(arivatwin)$"

SRCDATE = "20191212"

SRC_URI[md5sum] = "8b931568b4da580efa3026c5a9dcc7c4"
SRC_URI[sha256sum] = "e6b655071143b430bbdd14c90719746c62e608f636e7c199807ab4e7a27fd3e5"
