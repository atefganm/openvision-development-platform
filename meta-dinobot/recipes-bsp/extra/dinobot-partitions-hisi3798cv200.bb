SRCDATE = "20190716"
SRCDATE_dinobot4kse = "20180928"

SRC_URI[newgeneration.md5sum] = "0cf44e0fc8dec29539f1a40af3a8a96f"
SRC_URI[newgeneration.sha256sum] = "a55964f609c6ef521f5992ad8ace2d788d970c1df01f12dde36ab20729477eb1"
SRC_URI[dinobot4kse.md5sum] = "85f6efc8ae5926dcb6391e09a58b1fbf"
SRC_URI[dinobot4kse.sha256sum] = "1441e59ea5adb3577b8f6e7936cbffc249656d42a8fabc78033b37fc645e4548"

require dinobot-partitions.inc
