SRCDATE = "20151211"

require odin-dvb-modules.inc

MACHINETYPE = "e3hd"

SRC_URI[md5sum] = "8573ffb0eeefd76f356a1416651f8cdd"
SRC_URI[sha256sum] = "8fa8f4b4be742d410228c1bd0a9149e66e6cb076b55869b107b019a14770b1a3"

COMPATIBLE_MACHINE = "^(axase3)$"
