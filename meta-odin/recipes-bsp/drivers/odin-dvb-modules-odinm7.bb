SRCDATE = "20151211"

require odin-dvb-modules.inc

MACHINETYPE = "odinm7"

SRC_URI[md5sum] = "bb2cc9bc3d05195be9974d72d28b0647"
SRC_URI[sha256sum] = "b15bfc3519e555cad9d4608e53a66306541c05bbd96382838f188d7501c128b7"

COMPATIBLE_MACHINE = "^(axodin)$"
