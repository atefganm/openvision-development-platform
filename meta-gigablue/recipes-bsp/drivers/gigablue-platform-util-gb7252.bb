require gigablue-platform-util.inc

GBPLATFORM = "gb7252"

SRCDATE = "20200723.r0"

SRC_URI[md5sum] = "4fad8bd16b120a177288dee7b34e7193"
SRC_URI[sha256sum] = "19d1a4c9905c47ecd333d8bda0fc905130699fb33afd8b85b28d53a9aaf5a62a"

COMPATIBLE_MACHINE = "^(gbquad4k|gbue4k)$"
