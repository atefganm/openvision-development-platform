require gigablue-partitions-gbmv200.inc

COMPATIBLE_MACHINE = "^(gbip4k)$"

SRCDATE = "20201218"

SRC_URI[md5sum] = "5b743758e616c08f214eed0c12a42b7e"
SRC_URI[sha256sum] = "9e3b0b94930455a757611fd4dddea620d6a1fae9e76bc1744c177e96aeb580d3"
