require gigablue-partitions-gbmv200.inc

COMPATIBLE_MACHINE = "^(gbtrio4k)$"

SRCDATE = "20201218"

SRC_URI[md5sum] = "e69a6ae4bc3f461f1e51ce826b4d858d"
SRC_URI[sha256sum] = "90988a9f7afc8d7d403b2a56c631a1390610106511448a3b2591197e269d3d62"
