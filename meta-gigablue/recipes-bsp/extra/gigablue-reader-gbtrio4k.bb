require gigablue-reader-gbmv200.inc

COMPATIBLE_MACHINE = "^(gbtrio4k)$"

SRCDATE = "20200612"

SRC_URI[md5sum] = "979968a04bc0a04b856dfa13c6735bd7"
SRC_URI[sha256sum] = "22711ee3d0e0956665becee8527dc2ea2ac7728ab909feded518ae38faa76bf4"
