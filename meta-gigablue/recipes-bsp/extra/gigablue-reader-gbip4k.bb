require gigablue-reader-gbmv200.inc

COMPATIBLE_MACHINE = "^(gbip4k)$"

SRCDATE = "20200612"

SRC_URI[md5sum] = "1f1e2bd8145e7580ed1b0ee65afd192f"
SRC_URI[sha256sum] = "7603bfa5ba642819a33edcec7a84e67d67d2f23a7605156d6460cdc38b2fe37d"
